Commit message: jenga brick was way too heavy

File: data/jenga/jenga.urdf (robot description, URDF)
Before this commit: robot jenga.urdf, 1 links, 0 joints
Links:
- link baseLink: mass 1.0 -> .05
